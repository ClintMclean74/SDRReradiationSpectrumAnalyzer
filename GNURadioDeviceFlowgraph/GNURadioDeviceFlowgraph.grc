options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: bb_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '1000'
    value: '56'
  states: {}
- name: flow_graph_ID
  id: variable
  parameters:
    value: '"GNURADIODEVICE"'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '96400'
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '1000'
    value: '27'
  states: {}
- name: localAddress
  id: variable
  parameters:
    value: '"127.0.0.1"'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '1000'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '20000'
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '4321'
    send_eof: 'False'
    type: complex
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: bb_gain
    dc_offset_mode0: '2'
    freq0: freq * 1000
    gain0: rf_gain
    gain_mode0: 'True'
    if_gain0: if_gain
    iq_balance_mode0: '2'
    sample_rate: samp_rate * 1000
    sync: sync
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate * 1000
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {}
- name: xmlrpc_server_0_0_0
  id: xmlrpc_server
  parameters:
    addr: 127.0.0.1
    port: '54321'
  states: {}

connections:
- [osmosdr_source_0, '0', network_udp_sink_0, '0']
- [osmosdr_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
